# Keil uVision project U_T.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: U_T +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: u_t.c
    ../温度和光照/工程文件--C语言版/光敏+热敏Demo/: STC15F2K60S2.H
