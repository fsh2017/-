# Keil uVision project ADXL345.uvproj, settings and files
target ADXL345 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: ADXL345 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Func;..\HardWare;..\User
  group User
    ./: Main.c
  group Func
    ../Func/: ADXL345_Func.c Delay.c
  group HardWare
    ../HardWare/: ADXL345.c Key.c LED.c Timer.c
